# Keil uVision project stm32f103c8.uvprojx, settings and files
target stm32f103c8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\CMSIS;..\hardware\EXTI;..\hardware\iwdg;..\hardware\jdq;..\hardware\KEY;..\hardware\LED;..\hardware\sys;..\hardware\TIMER;..\hardware\usart;..\Lib\inc;..\Lib\src;..\Startup;..\User;..\hardware\RTC;..\hardware\beep;..\hardware\door;..\hardware\dht11;..\hardware\adc;..\Gizwits;..\Utils;..\hardware\DS18B20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_dma.c
  group hardware
    ../hardware/usart/: delay.c usart.c usart3.c
    ../hardware/EXTI/: exti.c
    ../hardware/iwdg/: iwdg.c
    ../hardware/jdq/: jdq.c
    ../hardware/KEY/: key.c
    ../hardware/LED/: led.c
    ../hardware/sys/: sys.c
    ../hardware/TIMER/: timer.c
    ../hardware/RTC/: rtc.c
    ../hardware/beep/: beep.c
    ../hardware/door/: door.c
    ../hardware/dht11/: DHT11.c
    ../hardware/adc/: adcx.c
    ../hardware/DS18B20/: ds18b20.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
software components: CMSIS:CORE 5.3.0
